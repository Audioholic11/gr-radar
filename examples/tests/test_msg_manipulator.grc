<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_msg_manipulator</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>5.7e9</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>const_add</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>const_mult</value></param>
<param><key>value</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimator_fac</value></param>
<param><key>value</key><value>2**0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>(-10000,10000)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_res</value></param>
<param><key>value</key><value>samp_rate/float(packet_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>max_output_buffer</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>min_output_buffer</value></param>
<param><key>value</key><value>int(packet_len*2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packet_len</value></param>
<param><key>value</key><value>2**15</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>range_res</value></param>
<param><key>value</key><value>3e8/2/float((freq[1]-freq[0]))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>250000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_res</value></param>
<param><key>value</key><value>packet_len/float(samp_rate)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>v_res</value></param>
<param><key>value</key><value>freq_res*3e8/2/center_freq</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>value_range</value></param>
<param><key>value</key><value>2000</value></param>
<param><key>label</key><value>range</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>100</value></param>
<param><key>stop</key><value>10000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>vel</value></param>
<param><key>value</key><value>50</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-50</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>50</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>10</value></param>
<param><key>maxoutbuf</key><value>max_output_buffer</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>maxoutbuf</key><value>max_output_buffer</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>c</key><value>1/float(decimator_fac)</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>maxoutbuf</key><value>max_output_buffer</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decimator_fac</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>packet_len/decimator_fac</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>radar_estimator_cw</key>
<param><key>id</key><value>radar_estimator_cw_0</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
</block>
<block>
<key>radar_msg_manipulator</key>
<param><key>id</key><value>radar_msg_manipulator_0</value></param>
<param><key>const_add</key><value>(const_add,)</value></param>
<param><key>symbols</key><value>('velocity',)</value></param>
<param><key>const_mult</key><value>(const_mult,)</value></param>
</block>
<block>
<key>radar_os_cfar_c</key>
<param><key>id</key><value>radar_os_cfar_c_0</value></param>
<param><key>samp_compare</key><value>10</value></param>
<param><key>merge_consecutive</key><value>True</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>mult_threshold</key><value>20</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_protect</key><value>0</value></param>
<param><key>rel_threshold</key><value>0.78</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_print_results</key>
<param><key>id</key><value>radar_print_results_1</value></param>
<param><key>store_msg</key><value>False</value></param>
</block>
<block>
<key>radar_qtgui_scatter_plot</key>
<param><key>id</key><value>radar_qtgui_scatter_plot_0</value></param>
<param><key>axis_x</key><value>-50,50</value></param>
<param><key>axis_y</key><value>-1,1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label_x</key><value>'velocity'</value></param>
<param><key>label_y</key><value>'y'</value></param>
<param><key>interval</key><value>250</value></param>
</block>
<block>
<key>radar_qtgui_time_plot</key>
<param><key>id</key><value>radar_qtgui_time_plot_0</value></param>
<param><key>axis_y</key><value>-50,50</value></param>
<param><key>label_y</key><value>'velocity'</value></param>
<param><key>range_time</key><value>10</value></param>
<param><key>interval</key><value>250</value></param>
</block>
<block>
<key>radar_signal_generator_cw_c</key>
<param><key>id</key><value>radar_signal_generator_cw_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>maxoutbuf</key><value>max_output_buffer</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_len</key><value>packet_len</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>radar_static_target_simulator_cc</key>
<param><key>id</key><value>radar_static_target_simulator_cc_0</value></param>
<param><key>azimuth</key><value>0,</value></param>
<param><key>center_freq</key><value>center_freq</value></param>
<param><key>maxoutbuf</key><value>max_output_buffer</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>rcs</key><value>1e20, </value></param>
<param><key>rndm_phaseshift</key><value>True</value></param>
<param><key>range</key><value>value_range,</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>self_coupling_db</key><value>-10</value></param>
<param><key>self_coupling</key><value>False</value></param>
<param><key>velocity</key><value>vel, </value></param>
</block>
<block>
<key>radar_ts_fft_cc</key>
<param><key>id</key><value>radar_ts_fft_cc_0</value></param>
<param><key>minoutbuf</key><value>min_output_buffer</value></param>
<param><key>len_key</key><value> "packet_len"</value></param>
<param><key>packet_len</key><value>packet_len/decimator_fac</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>decimator_fac</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>radar_ts_fft_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>radar_static_target_simulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_estimator_cw_0</source_block_id><sink_block_id>radar_msg_manipulator_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_cw_0</source_block_id><sink_block_id>radar_qtgui_scatter_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_estimator_cw_0</source_block_id><sink_block_id>radar_qtgui_time_plot_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_msg_manipulator_0</source_block_id><sink_block_id>radar_print_results_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_os_cfar_c_0</source_block_id><sink_block_id>radar_estimator_cw_0</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_os_cfar_c_0</source_block_id><sink_block_id>radar_print_results_1</sink_block_id><source_key>Msg out</source_key><sink_key>Msg in</sink_key></connection>
<connection><source_block_id>radar_signal_generator_cw_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_static_target_simulator_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_ts_fft_cc_0</source_block_id><sink_block_id>radar_os_cfar_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
