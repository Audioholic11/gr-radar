<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_split_cc</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>20.48e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>t_CW</value></param>
<param><key>value</key><value>.000001</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>t_dchirp</value></param>
<param><key>value</key><value>50e-6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>t_uchirp</value></param>
<param><key>value</key><value>.00005</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>target_range</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>.1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>target_vel</value></param>
<param><key>value</key><value>5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>.1</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>1000</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>CW</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>Down_Chirp</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>Rx</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>100</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>Tx</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>showrf</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>rate</key><value>100</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>Up_Chirp</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>.001</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_conjugate_cc</key>
<param><key>id</key><value>blocks_multiply_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>radar_signal_generator_fmcw_c</key>
<param><key>id</key><value>radar_signal_generator_fmcw_c_0</value></param>
<param><key>amplitude</key><value>1</value></param>
<param><key>freq_cw</key><value>0</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>samp_rate</key><value>int(samp_rate)</value></param>
<param><key>samp_cw</key><value>int(t_CW*samp_rate)</value></param>
<param><key>samp_down</key><value>int(t_dchirp*samp_rate)</value></param>
<param><key>samp_up</key><value>int(t_uchirp*samp_rate)</value></param>
<param><key>freq_sweep</key><value>samp_rate/4</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>0</value></param>
<param><key>packet_parts</key><value>(int(t_CW*samp_rate),int(t_uchirp*samp_rate),int(t_dchirp*samp_rate))</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_0</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>1</value></param>
<param><key>packet_parts</key><value>(int(t_CW*samp_rate),int(t_uchirp*samp_rate),int(t_dchirp*samp_rate))</value></param>
</block>
<block>
<key>radar_split_cc</key>
<param><key>id</key><value>radar_split_cc_0_1</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>packet_num</key><value>2</value></param>
<param><key>packet_parts</key><value>(int(t_CW*samp_rate),int(t_uchirp*samp_rate),int(t_dchirp*samp_rate))</value></param>
</block>
<block>
<key>radar_static_target_simulator_cc</key>
<param><key>id</key><value>radar_static_target_simulator_cc_0</value></param>
<param><key>azimuth</key><value>0</value></param>
<param><key>center_freq</key><value>3.25e9</value></param>
<param><key>len_key</key><value>"packet_len"</value></param>
<param><key>rcs</key><value>1e12</value></param>
<param><key>rndm_phaseshift</key><value>True</value></param>
<param><key>range</key><value>target_range</value></param>
<param><key>samp_rate</key><value>int(samp_rate)</value></param>
<param><key>self_coupling_db</key><value>-10</value></param>
<param><key>self_coupling</key><value>True</value></param>
<param><key>velocity</key><value>target_vel</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>Rx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>radar_split_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>radar_split_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_conjugate_cc_0</source_block_id><sink_block_id>radar_split_cc_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>Tx</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_multiply_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_signal_generator_fmcw_c_0</source_block_id><sink_block_id>radar_static_target_simulator_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>CW</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_0</source_block_id><sink_block_id>Up_Chirp</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_1</source_block_id><sink_block_id>Down_Chirp</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_split_cc_0_1</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>radar_static_target_simulator_cc_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
